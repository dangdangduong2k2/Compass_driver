<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\compass_V1.ewp</path>
  </project>
  <batchBuild />
</workspace>
